FILESEXTRAPATHS:prepend:garmin := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:garmin = "garmin"
