FILESEXTRAPATHS:prepend:garmin := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:garmin = " file://default.conf"
