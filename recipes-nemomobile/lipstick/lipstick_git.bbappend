RDEPENDS:${PN}:append:garmin = " qt5-qpa-hwcomposer-plugin "
