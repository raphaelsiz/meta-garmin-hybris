FILESEXTRAPATHS:prepend:garmin := "${THISDIR}/usb-moded:"
