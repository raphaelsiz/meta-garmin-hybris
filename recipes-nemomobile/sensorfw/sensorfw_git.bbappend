DEPENDS:append:garmin = " libhybris "
