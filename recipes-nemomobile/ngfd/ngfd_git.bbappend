RDEPENDS:${PN}:append:garmin = " ngfd-plugin-droid-vibrator "
