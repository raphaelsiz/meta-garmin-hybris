RDEPENDS:pulseaudio-server:append:garmin = "pulseaudio-modules-droid"
